# Keil uVision project TEST.uvprojx, settings and files
target TEST (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L475VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: TEST +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L475xx LV_CONF_INCLUDE_SIMPLE LV_LVGL_H_INCLUDE_SIMPLE,STM32L475xx
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FreeMaster/src/common;../Middlewares/Third_Party/FreeMaster/src/port;../Middlewares/Third_Party/LVGL/port;../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src;../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/extra/themes/default;../Middlewares/Third_Party/LVGL/app
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
  group Application/User/Core
    ../Core/Src/: dc_control.c main.c freertos.c stm32l4xx_it.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_ll_usb.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/FreeMaster
    ../Middlewares/Third_Party/FreeMaster/src/common/: freemaster_appcmd.c freemaster_can.c freemaster_pdbdm.c freemaster_pipes.c freemaster_protocol.c freemaster_rec.c freemaster_scope.c freemaster_serial.c freemaster_sha.c freemaster_tsa.c freemaster_ures.c freemaster_utils.c
    ../Middlewares/Third_Party/FreeMaster/src/port/: freemaster_stm32l4_uart.c
  group Middleware/LVGL_core
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group Middleware/LVGL_draw
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group Middleware/LVGL_extra
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/extra/: lv_extra.c
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/extra/layouts/flex/: lv_flex.c
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/extra/layouts/grid/: lv_grid.c
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/extra/themes/default/: lv_theme_default.c
  group Middleware/LVGL_font
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/font/: lv_font_unscii_16.c lv_font_unscii_8.c lv_font_simsun_16_cjk.c lv_font_montserrat_48.c lv_font_montserrat_46.c lv_font_montserrat_44.c lv_font_montserrat_42.c lv_font_montserrat_40.c lv_font_montserrat_38.c lv_font_montserrat_36.c lv_font_montserrat_34.c lv_font_montserrat_32.c lv_font_montserrat_30.c lv_font_montserrat_28_compressed.c lv_font_montserrat_28.c lv_font_montserrat_26.c lv_font_montserrat_24.c lv_font_montserrat_22.c lv_font_montserrat_20.c lv_font_montserrat_18.c lv_font_montserrat_16.c lv_font_montserrat_14.c lv_font_montserrat_12_subpx.c lv_font_montserrat_12.c lv_font_montserrat_10.c lv_font_montserrat_8.c lv_font_loader.c lv_font_fmt_txt.c lv_font_dejavu_16_persian_hebrew.c lv_font.c
  group Middleware/LVGL_hal
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group Middleware/LVGL_misc
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group Middleware/LVGL_widgets
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/extra/widgets/led/: lv_led.c
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/extra/widgets/animimg/: lv_animimg.c
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/extra/widgets/chart/: lv_chart.c
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/extra/widgets/list/: lv_list.c
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/extra/widgets/menu/: lv_menu.c
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/extra/widgets/meter/: lv_meter.c
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/extra/widgets/span/: lv_span.c
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/extra/widgets/spinner/: lv_spinner.c
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/extra/widgets/tabview/: lv_tabview.c
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/extra/widgets/tileview/: lv_tileview.c
    ../Middlewares/Third_Party/LVGL/lvgl-release-v8.3/src/extra/widgets/win/: lv_win.c
  group Middleware/LVGL_port
    ../Middlewares/Third_Party/LVGL/port/: lv_port_disp.c drv_lcd.c
  group Middleware/LVGL_app
    ../Middlewares/Third_Party/LVGL/app/: lv_demo_stress.c lv_gui.c lv_app.c
software components: CMSIS:CORE 4.3.0
